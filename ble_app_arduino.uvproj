# Keil uVision project ble_app_arduino.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_arduino +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice;..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./: main.cpp HardwareSerial.cpp Arduino.cpp io.cpp
  group Library
    ../../../../../Source/simple_uart/: simple_uart.c
  group Include
    ../: HardwareSerial.h Arduino.h
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: ble_app_proximity +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
